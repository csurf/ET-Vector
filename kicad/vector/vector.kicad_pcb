# Repository csurf/ET-Vector (continued)

## KiCad design kicad/vector/vector.kicad_pcb (continued)

Schematic: pic32mx_2.kicad_sch

Parts:
C60, C62, C63: 0.1UF; C_0402_1005Metric
U9: PIC32MX695F512L-80I-PT_UNIT; TQFP-100_12x12mm_P0.4mm

Connections:
+3V3: C60.1, C62.1, C63.1, U9.30 (AVDD), U9.37 (VDD), U9.46 (VDD); also elsewhere on the board
GND: C60.2, C62.2, C63.2, U9.31 (AVSS), U9.36 (VSS), U9.45 (VSS); also elsewhere on the board
PIC32MX_P26: U9.26 (PGEC2/AN6/OCFA/RB6); also elsewhere on the board
PIC32MX_P27: U9.27 (PGED2/AN7/RB7); also elsewhere on the board
PIC32MX_P32: U9.32 (AN8/C1OUT/RB8); also elsewhere on the board
PIC32MX_P33: U9.33 (AN9/C2OUT/RB9); also elsewhere on the board
PIC32MX_P34: U9.34 (AN10/CVREFOUT/PMA13/RB10); also elsewhere on the board
PIC32MX_P35: U9.35 (AN11/ERXERR/AETXERR/PMA12/RB11); also elsewhere on the board
PIC32MX_P39: U9.39 (SCK3A/U3BTX/~U3ARTS/RF13); also elsewhere on the board
PIC32MX_P40: U9.40 (~SS3A/U3BRX/U3ACTS/RF12); also elsewhere on the board
PIC32MX_P44: U9.44 (AN15/ERXD3/AETXD2/OCFB/PMALL/PMA0/CN12/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); also elsewhere on the board
PIC32MX_P47: U9.47 (AETXD0/~SS1A/U1BRX/U1ACTS/CN20/RD14); also elsewhere on the board
PIC32MX_P49: U9.49 (SDA3A/SDI3A/U3ARX/PMA9/CN17/RF4); also elsewhere on the board
PIC32MX_P50: U9.50 (SCL3A/SDO3A/U3ATX/PMA8/CN18/RF5); also elsewhere on the board

Board: 2 copper layers, 179 parts (122 on the bottom side), 143 nets, no tracks yet.
